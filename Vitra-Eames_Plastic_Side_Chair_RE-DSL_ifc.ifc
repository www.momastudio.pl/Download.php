Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 198c56cc-445b-4aef-aecb-5a0c653a41a4, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: Vitra-Eames_Plastic_Chair-DSL-RE_rfa.ifc
Time: 2025-05-07T16:33:46
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1; sets with these values: 2
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 305
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Other(Type) - Category: Levels; Family Name: Level

# IfcFurnishingElement: Vitra-Eames_Plastic_Chair-DSL-RE_rfa:Eames plastic side chair DSL, Vitra-Eames_Plastic_Chair-DSL-RE_rfa:Eames plastic side chair DSL:379293
In: Level 1
Type - Material: 01 chrome
Type - General - Author: BIMStone; BIMObjectName: Vitra-Eames_Plastic_Side_Chair-DSR-RE; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: The so-called Eiffel Tower base of the DSR chair (Dining Height Side Chair Rod Base), an intricate and graceful construction made of steel wire, combines light, elegant forms with structural strength.; Revision: n/a; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Dining chairs; Uniclass2015Reference: Pr_40_50_12_22; Version: 1; VersionDate: 05/05/2025
Type - Constraints - Default Elevation: 0 mm
Type - Materials and Finishes - ChairTertiaryMaterial: 01 chrome
Type - Construction - SeatCushionVisibility: no; Upholstered: no
Type - Identity Data - Collection: Eames plastic side chair; Cost: 0; Description: The so-called Eiffel Tower base of the DSR chair (Dining Height Side Chair Rod Base), an intricate and graceful construction made of steel wire, combines light, elegant forms with structural strength. The organically shaped plastic seat shell is available in various colours and upholstery options, allowing this distinctive classic by Charles and Ray Eames to be adapted to a wide range of individual needs and preferences.; Designer: Charles & Ray Eames; Manufacturer: Vitra; Model: Eames plastic side chair DSL; OmniClass Number: 23.40.20.14.14.11; ProductDatasheet: https://www.vitra.com/en-un/_storage/asset/970265/storage/master/download/Factbook%20EPC-EN.pdf; Type Name: Eames plastic side chair DSL; URL: https://www.vitra.com/en-un/living/product/details/eames-plastic-side-chair-dsr
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Eames_Plastic_Chair-DSL-RE_rfa; Features: Optional seat cushion or full upholstery.; Finish: Seat shell: dyed-through polypropylene. All models are available with a seat cushion (screwed to the seat shell) or full upholstery. The fully upholstered version has moulded polyurethane foam padding covered in fabric, attached to the shell with a welted edge. Different shell and upholstery colours and various bases provide a multitude of possible combinations. Options: the Eames Plastic Chair is available as a visitor chair, dining chair, rocking chair, swivel chair or in stacking versions and with ganging brackets for row seating. Beam-mounted shells are suited for use in waiting areas. Base: non-stacking four-legged wire base with cross struts. The powder-coated version is suitable for outdoor use. (DSR = Dining Height Side Chair Rod Base). Note: special additives retard the fading of colours due to UV radiation. However, if the chair is exposed to sunlight for prolonged periods, the colour may change over time. We recommend limited exposure to sunlight.; Grade: n/a; ModelNumber: n/a; ModelReference: n/a; Name: Eames_Plastic_Side_Chair-DSR-RE; ReplacementCost: n/a; Shape: Sculptured; Size: 465x550xH mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Various
Type - Pset_FurnitureTypeCommon - Description: The so-called Eiffel Tower base of the DSR chair (Dining Height Side Chair Rod Base), an intricate and graceful construction made of steel wire, combines light, elegant forms with structural strength. The organically shaped plastic seat shell is available in various colours and upholstery options, allowing this distinctive classic by Charles and Ray Eames to be adapted to a wide range of individual needs and preferences.; Style: n/a; NominalHeight: 741.8 mm; NominalLength: 465 mm; NominalDepth: 550 mm; MainColor: Various
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Type - Pset_ProductRequirements - Name: Eames_Plastic_Side_Chair-DSR-RE
Material: 01 chrome, Glide black, 01 basic dark
Pset_FurnitureTypeChair - SeatingHeight: 393.1 mm; HighestSeatingHeight: 393.1 mm; LowestSeatingHeight: 393.1 mm
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_QuantityTakeOff - Reference: Eames plastic side chair DSL
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Phasing - Phase Created: New Construction
Materials and Finishes - ChairMainMaterial: 01 basic dark; ChairQuaternaryMaterial: Glide black; ChairSecondaryMaterial: Textile hopsak blue moor 84
Construction - LegHeight: 357.3 mm; NominalHeightControl: 741.8 mm
Dimensions - Area: 1.00868 m2; Volume: 0.189715 m3
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Vitra-Eames_Plastic_Chair-DSL-RE_rfa; Family and Type: Vitra-Eames_Plastic_Chair-DSL-RE_rfa: Eames plastic side chair DSL; InstallationDate: n/a; Material: Polypropylene & aluminium; SerialNumber: n/a; TagNumber: n/a; Type: Eames plastic side chair DSL; Type Id: 379267; WarrantyStartDate: n/a
